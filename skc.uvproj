# Keil uVision project skc.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC847 Analog Devices
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0xF7FF) CLOCK(32768) DPX MODAB2
  output: skc +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: START_AD.A51 skc.c frequency.c timer1.c timer2.c skc.h tic.c
